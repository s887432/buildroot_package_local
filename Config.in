## Config.in
```kconfig
config BR2_PACKAGE_HELLOWORLD
    bool "helloworld"
    help
        buildroot test package.

        https://www.linux4sam.org
```
